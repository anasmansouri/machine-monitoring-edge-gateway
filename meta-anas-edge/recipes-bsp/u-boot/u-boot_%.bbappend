FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://custom-bootdelay.cfg"
